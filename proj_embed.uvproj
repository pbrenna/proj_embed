# Keil uVision project proj_embed.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: proj_embed
  c flags: Optimize=9
  group Source Group 1
    ./: main.c ev.c init.c i2c_machine.c display.c thermometer.c util.c accel.c
